# Keil uVision project Project.uvprojx, settings and files
target Discover-More (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,__FPU_PRESENT,__FPU_USED,DHCP,USER_DEBUG
  c include: ..\inc;..\src;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\lwip_v1.3.2\src\include;..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\lwip_v1.3.2\src\include\ipv4\lwip;..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\Utilities\FreeRTOSv10.0.1\include;..\..\Utilities\FreeRTOSv10.0.1\portable\RVDS\ARM_CM4F;..\..\Utilities\MQTTClient\MQTTPacket\src;..\..\Utilities\MQTTClient\MQTTClient-C\src;..\..\Utilities\MQTTClient\MQTTClient-C\src\FreeRTOS;..\libraries\inc;..\drivers\inc;..\..\Utilities\RS485_BUS\port\rtos;..\..\Utilities\RS485_BUS\Interface\include;..\..\Utilities\RS485_BUS\Interface\rtu;..\..\Utilities\RS485_BUS\Interface\ascii;..\..\Utilities\RS485_BUS\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c netconf.c stm32f4x7_eth_bsp.c fs.c httpserver-socket.c miscellaneous.c hw_config.c api_server.c MQTTClientTask.c key_scan.c keyscan_task.c RS485bus_task_m.c RS485bus_task.c TCPMBbus_task.c
  group MQTTClient
    ../../Utilities/MQTTClient/MQTTClient-C/src/: MQTTClient.c
    ../../Utilities/MQTTClient/MQTTClient-C/src/FreeRTOS/: MQTTFreeRTOS.c
  group MQTTPacket
    ../../Utilities/MQTTClient/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group RS485Bus
    ../../Utilities/RS485_BUS/Interface/rtu/: rs485crc.c rs485rtu_m.c rs485crc.h rs485rtu.c
    ../../Utilities/RS485_BUS/Interface/functions/: rs485utils.c rs485funcPeriodicPing_m.c rs485funcErrodetect_m.c rs485funccheck_m.c rs485funcNFCdetect_m.c rs485funcPeriodicPing.c mbfuncholding_m.c
    ../../Utilities/RS485_BUS/Interface/: RS485Bus_m.c RS485Bus.c
    ../../Utilities/RS485_BUS/Interface/include/: rs485_m.h rs485config.h rs485.h
    ../../Utilities/RS485_BUS/port/rtos/: portother _m.c portserial_m.c porttimer_m.c portevent_m.c port.h portother.c portserial.c porttimer.c portevent.c
    ../../Utilities/RS485_BUS/port/: user_rs485_app_m.c user_rs485_app.h user_rs485_app.c
  group LWIP
    ../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Utilities/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../Utilities/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F4-Discovery
    ../src/: stm32f4xx_uartstdio.c tm_stm32f4_i2c.c
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c
  group STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group FreeRTOS
    ../../Utilities/FreeRTOSv10.0.1/: croutine.c list.c queue.c tasks.c event_groups.c stream_buffer.c timers.c
    ../../Utilities/FreeRTOSv10.0.1/portable/RVDS/ARM_CM4F/: port.c
    ../../Utilities/FreeRTOSv10.0.1/portable/MemMang/: heap_2.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group Readme
    ../: readme.txt
  group TCP_BUS
    ../../Utilities/TCP_BUS/Interface/: tcp_mb.c
    ../../Utilities/TCP_BUS/Interface/tcp/: mbtcp.c
    ../../Utilities/TCP_BUS/port/: port_tcp.c portevent_tcp.c portother_tcp.c
    ../../Utilities/TCP_BUS/Interface/function/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
target Master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: Project +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,__FPU_PRESENT,__FPU_USED,DHCP,USER_DEBUG,MASTER
  c include: ..\inc;..\src;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\lwip_v1.3.2\src\include;..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\lwip_v1.3.2\src\include\ipv4\lwip;..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\Utilities\FreeRTOSv10.0.1\include;..\..\Utilities\FreeRTOSv10.0.1\portable\RVDS\ARM_CM4F;..\..\Utilities\MQTTClient\MQTTPacket\src;..\..\Utilities\MQTTClient\MQTTClient-C\src;..\..\Utilities\MQTTClient\MQTTClient-C\src\FreeRTOS;..\libraries\inc;..\drivers\inc;..\..\Utilities\RS485_BUS\port\rtos;..\..\Utilities\RS485_BUS\Interface\include;..\..\Utilities\RS485_BUS\Interface\rtu;..\..\Utilities\RS485_BUS\Interface\ascii;..\..\Utilities\RS485_BUS\port;..\..\Utilities\TCP_BUS\Interface\Include;..\..\Utilities\TCP_BUS\Interface\tcp;..\..\Utilities\TCP_BUS\port;..\..\Utilities\TCP_BUS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Slave (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: Project +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,__FPU_PRESENT,__FPU_USED,DHCP,USER_DEBUG, SLAVE
  c include: ..\inc;..\src;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\lwip_v1.3.2\src\include;..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\lwip_v1.3.2\src\include\ipv4\lwip;..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\Utilities\FreeRTOSv10.0.1\include;..\..\Utilities\FreeRTOSv10.0.1\portable\RVDS\ARM_CM4F;..\..\Utilities\MQTTClient\MQTTPacket\src;..\..\Utilities\MQTTClient\MQTTClient-C\src;..\..\Utilities\MQTTClient\MQTTClient-C\src\FreeRTOS;..\libraries\inc;..\drivers\inc;..\..\Utilities\RS485_BUS\port\rtos;..\..\Utilities\RS485_BUS\Interface\include;..\..\Utilities\RS485_BUS\Interface\rtu;..\..\Utilities\RS485_BUS\Interface\ascii;..\..\Utilities\RS485_BUS\port;..\..\Utilities\TCP_BUS\Interface\Include;..\..\Utilities\TCP_BUS\Interface\tcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
